options:
  parameters:
    generate_options: qt_gui
    id: default
    output_language: python
    title: LoRa receiver for PlutoSDR
  states: {}

blocks:
- name: capture_freq
  id: variable
  parameters:
    value: '868100000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: capture_freq
    freq_span: samp_rate
  states: {state: disabled}
- name: gain
  id: parameter
  parameters:
    label: RX Gain
    short_id: g
    type: eng_float
    value: '50'
  states: {}
- name: iio_pluto_source_0_0
  id: iio_pluto_source
  parameters:
    bandwidth: samp_rate
    bbdc: 'True'
    buffer_size: 2**16
    filter_source: '''Auto'''
    frequency: int(capture_freq)
    gain1: '''manual'''
    len_tag_key: ''
    manual_gain1: gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:pluto.local
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.1'
    bw: samp_rate
    fc: capture_freq
    fftsize: '1024'
    grid: 'True'
    name: '"spectrum"'
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: capture_freq
    fftsize: '1024'
    showrf: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: '"waterfall"'
    type: complex
  states: {}

connections:
- [iio_pluto_source_0_0, '0', fosphor_qt_sink_c_0, '0']
- [iio_pluto_source_0_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0_0, '0', qtgui_sink_x_0, '0']
- [iio_pluto_source_0_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
